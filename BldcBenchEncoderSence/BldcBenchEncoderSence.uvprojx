# Keil uVision project BldcBenchEncoderSence.uvprojx, settings and files
target BldcBenchEncoderSence (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BldcBenchEncoderSence
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Code\inc;.\Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Code
    ./Code/src/: main.c
  group Lib
    ./Lib/src/: bsp.c delay.c encoder.c MCP.c MotorControl.c rcc.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
